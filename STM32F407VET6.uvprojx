# Keil uVision project STM32F407VET6.uvprojx, settings and files
target AIX_RX (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VET6 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: .\APPS;.\CORE;.\FWlib\inc;.\USER;.\HARDWARE;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT;.\APPS;.\AIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ./: READ ME.txt
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group HARDWARE
    ./HARDWARE/: SPI.c LED.c UART1.c UART2.c UART3.c TIMER2.c RNG.c
  group AIS
    ./AIS/: AIS_PS_Struct.c FSMControl.c MKDControl.c PS_FPGA_Interface.c test.c testFSMControl.c test_MKD.c testMKDControl.c
  group APP
    ./APPS/: APP.c
  group FWLIB
    ./FWlib/src/: misc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma.c
  group UCOSII-CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ./UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ./UCOSII/CONFIG/: includes.h os_cfg.h
